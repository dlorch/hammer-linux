## Kconfig
```kconfig
config HAMMER_FS
	tristate "HAMMER Filesystem (EXPERIMENTAL)"
	help
		HAMMER Filesystem

		If afraid, say N.
```
